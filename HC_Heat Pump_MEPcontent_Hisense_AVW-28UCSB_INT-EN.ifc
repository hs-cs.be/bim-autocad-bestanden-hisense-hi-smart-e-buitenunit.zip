Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-03-12T09:58:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 12 09:58:49 2018 * Host: B3ROBRAWR3858 * Database: C:\Users\DD\AppData\Local\Temp\{723CB5B8-C14A-4BAF-ADD5-9E42A44B6EBA}\ifc * Database version: 5507 * Database creation date: Mon Mar 12 09:58:48 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Mar 12 09:58:48 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 12 09:58:48 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcPump: AVW-28UCSB, HC_Heat Pump_MEPcontent_Hisense_AVW28UCSB-43UESB_INT-EN:AVW-28UCSB:1300233
In: V00
Type - Material: Color RGB 000-204-204, Color RGB 216-216-216, Color RGB 024-077-198
Type - Dimensions - Depth: 370 mm; Drain Diameter: 32 mm; Height: 800 mm; Refrigerant Gas Diameter: 15.9 mm; Refrigerant Liquid Diameter: 9.53 mm; Width: 950 mm
Type - Electrical - ELB Nominal Current: 30 A; Hertz: 50 Hz; Maximum Running Current: 19.5 A; Phase: 1; Voltage: 230.002 V
Type - Identity Data - Article Description: Heat pump outdoor unit; Article Type: AVW-28UCSB; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Heat pump outdoor unit; EMCS Version: 3.0; ETIM Article Class: EC001213; Family Version: 11.13; Manufacturer: Hisense; Manufacturer Art. No.: AVW-28UCSB; Manufacturer URL: http://www.hs-cs.nl/; MEPcontent Class: HEATPUMP; Model: AVW-28UCSB; OmniClass Number: 23.75.10.21; OmniClass Title: Heat Pumps; Product Line: Hi-Smart E Series; Revit Version: 2016; Type Name: AVW-28UCSB; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Blue: Color RGB 024-077-198; Grey: Color RGB 080-080-080; Logo: Color RGB 000-204-204; White: Color RGB 216-216-216
Type - Mechanical - Loads - Airflow Rate (m3/min): 0; Compressor Motor Output (kW): 0; Cooling Capacity (kW): 8; Cooling EER (kW/kW): 2.93; Cooling Power Input (kW): 2.73; Cooling Sound Pressure Level (dB(A)): 50; External Static Pressure (Pa): 0; Fan Motor Output (kW): 0.051; Heating Capacity (kW): 9.5; Heating COP (kW/kW): 3.52; Heating Power Input (kW): 2.7; Heating Sound Pressure Level (dB(A)): 52; Unit Weight (kg): 65
Type - Other - Category: Mechanical Equipment; Family Name: HC_Heat Pump_MEPcontent_Hisense_AVW28UCSB-43UESB_INT-EN; Fan Quantity: 1; Fan Type: Axial-flow Fan; Refrigerant Charge (kg): 0; Refrigerant Type: R410A
Pset_ManufacturerTypeInformation - Manufacturer: Hisense
Constraints - Offset: 0 mm
Dimensions - Area: 5.16672 m2; Volume: 1.40393 m3
Electrical - Loads - Power: 0 W
Identity Data - Mark: 4
Mechanical - Drain Fixture Units: 0; Refrigerant Gas Flow: 0 m3/s; Refrigerant Liquid Flow: 0 m3/s; System Classification: Sanitary,Undefined,Power
Other - Back Clearance Safe: 300 mm; Family: HC_Heat Pump_MEPcontent_Hisense_AVW28UCSB-43UESB_INT-EN: AVW-28UCSB; Family and Type: HC_Heat Pump_MEPcontent_Hisense_AVW28UCSB-43UESB_INT-EN: AVW-28UCSB; Front Clearance Safe: 600 mm; Gas Connector Angle: 0 deg; Gas Connector Length: 60.5 mm; Left Clearance Safe: 50 mm; Liquid Connector Angle: 0 deg; Liquid Connector Length: 40.5 mm; Right Clearance Safe: 100 mm; Type: HC_Heat Pump_MEPcontent_Hisense_AVW28UCSB-43UESB_INT-EN: AVW-28UCSB; Type Id: HC_Heat Pump_MEPcontent_Hisense_AVW28UCSB-43UESB_INT-EN: AVW-28UCSB
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Back Clearance: 300 mm; Front Clearance: 600 mm; Front Connection: yes; Left Clearance: 50 mm; Rear Connection: no; Right Clearance: 100 mm; Right Connection: no; Service Area: no
